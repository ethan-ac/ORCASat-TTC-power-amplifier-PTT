options:
  parameters:
    author: ethan
    description: This block toggles the RTS# pin of a USB/serial cable (cable_file) when samples pass it (amp_tx) and for a predetermined duration before (pre_tx) and after (post_tx) the samples pass
    generate_options: hb
    id: ptt_hier
    output_language: python
    title: Power Amplifier PTT
  states: {}

blocks:
- name: ampkey_amp_ptt_0
  id: ampkey_amp_ptt
  parameters:
    file: cable_file
    num_ports: '1'
    post_tx: post_tx
    pre_tx: pre_tx
    type: complex
    vlen: '1'
  states: {}
- name: ampkey_samp_delay_0
  id: ampkey_samp_delay
  parameters:
    num_ports: '1'
    pre_tx: pre_tx
    samp_rate: samp_rate_usrp
    type: complex
    vlen: '1'
  states: {}
- name: cable_file
  id: parameter
  parameters:
    label: USB/serial Cable File
    type: str
    value: /dev/ptt
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: post_tx
  id: parameter
  parameters:
    label: Post Tx Delay (ms)
    type: eng_float
    value: '50'
  states: {}
- name: pre_tx
  id: parameter
  parameters:
    label: Pre Tx Delay (ms)
    type: eng_float
    value: '50'
  states: {}
- name: samp_rate_usrp
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '2000000'
  states: {}

connections:
- [ampkey_samp_delay_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', ampkey_amp_ptt_0, '0']
- [pad_source_0, '0', ampkey_samp_delay_0, '0']

metadata:
  file_format: 1
