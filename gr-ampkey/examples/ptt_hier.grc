options:
  parameters:
    author: ethan
    generate_options: qt_gui
    id: ptt_hier
    output_language: python
    title: Amplifier PTT
  states: {}

blocks:
- name: ampkey_keyer_0
  id: ampkey_keyer
  parameters:
    num_ports: '1'
    post_tx: post_tx
    pre_tx: pre_tx
    type: complex
    vlen: '1'
  states: {}
- name: ampkey_samp_delay_0
  id: ampkey_samp_delay
  parameters:
    num_ports: '1'
    pre_tx: pre_tx
    samp_rate: samp_rate_usrp
    type: complex
    vlen: '1'
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: mute
    type: complex
  states: {}
- name: mute
  id: parameter
  parameters:
    label: Mute
    value: 'False'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: post_tx
  id: parameter
  parameters:
    label: Post Tx Delay (ms)
    type: eng_float
    value: '50'
  states: {}
- name: pre_tx
  id: parameter
  parameters:
    label: Pre Tx Delay (ms)
    type: eng_float
    value: '50'
  states: {}
- name: samp_rate_usrp
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '2000000'
  states: {}

connections:
- [ampkey_samp_delay_0, '0', pad_sink_0, '0']
- [blocks_mute_xx_0, '0', ampkey_keyer_0, '0']
- [blocks_mute_xx_0, '0', ampkey_samp_delay_0, '0']
- [pad_source_0, '0', blocks_mute_xx_0, '0']

metadata:
  file_format: 1
